* C:\esimavkk\Flashadc\Flashadc.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 15:11:53

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X3  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC1-Pad2_ Net-_U3-Pad1_ GND avsd_opamp
X4  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC2-Pad2_ Net-_U3-Pad2_ GND avsd_opamp
X5  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC4-Pad2_ Net-_U3-Pad4_ GND avsd_opamp
X6  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC5-Pad2_ Net-_U3-Pad5_ GND avsd_opamp
X2  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC6-Pad2_ Net-_U3-Pad6_ GND avsd_opamp
X7  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC7-Pad2_ Net-_U3-Pad7_ GND avsd_opamp
X8  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC8-Pad1_ Net-_U3-Pad8_ GND avsd_opamp
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Vout1 Vout2 Vout3 priencode83
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC5  Net-_SC4-Pad2_ Net-_SC5-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC4  Net-_SC3-Pad2_ Net-_SC4-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC3  Net-_SC2-Pad2_ Net-_SC3-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC2  Net-_SC1-Pad2_ Net-_SC2-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC6  Net-_SC5-Pad2_ Net-_SC6-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC7  Net-_SC6-Pad2_ Net-_SC7-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
X1  Net-_SC1-Pad3_ Net-_X1-Pad2_ Vin Net-_SC3-Pad2_ Net-_U3-Pad3_ GND avsd_opamp
SC9  Net-_SC7-Pad2_ Net-_SC8-Pad1_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC8  Net-_SC8-Pad1_ GND Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
v2  Net-_SC1-Pad1_ GND DC
v1  Vin GND sine
v3  Net-_SC1-Pad3_ GND DC
v4  Net-_X1-Pad2_ GND DC
U5  Vout1 plot_v1
U6  Vout2 plot_v1
U7  Vout3 plot_v1
scmode1  SKY130mode
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U3-Pad8_ Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ adc_bridge_8
U1  Vin plot_v1

.end
